// Autonomous Maze Solving Robot        
    
    #define motor_left 10  
    #define motor_dir 11       
    #define l1 8  
    #define l2 9  
    #define d1 12 
    #define d2 7
 int spd=255;
 int cnt=120;
 int rot=120;
 int zlt=60;
 int thr=25;
    int trigger_front = 5; 
    int echo_front = 6;
    
    int trigger_left = A2;
    int echo_left = A3;
    
    int trigger_dir = A0;
    int echo_dir = A1;
    
       
    void setup()
    {
        pinMode(trigger_front, OUTPUT); 
        pinMode(echo_front, INPUT);
        pinMode(trigger_left, OUTPUT);
        pinMode(echo_left, INPUT);
        
        pinMode(trigger_dir, OUTPUT);
        pinMode(echo_dir, INPUT);
       
        pinMode(motor_left, OUTPUT);
        pinMode(motor_dir, OUTPUT);
        pinMode(A5,INPUT); 
        pinMode(A4,INPUT);  
        pinMode(l1, OUTPUT);
        pinMode(l2, OUTPUT); 
        pinMode(d1, OUTPUT);
        pinMode(d2, OUTPUT);     
        delay(5000);
        Serial.begin(9600);
    }
    
    
    void loop()
    {

     long duration_front, duration_left, duracao_dir, direita, left, front,i,j; 
     
     
     digitalWrite(trigger_front, LOW); 
     delayMicroseconds(2);              
     digitalWrite(trigger_front, HIGH);
     delayMicroseconds(5);              
     digitalWrite(trigger_front, LOW);  
     duration_front = pulseIn(echo_front, HIGH);
     front = duration_front/29/2;
    Serial.print(front);
    Serial.println("");
     digitalWrite(trigger_left, LOW);
     delayMicroseconds(2);
     digitalWrite(trigger_left, HIGH);
     delayMicroseconds(5);
     digitalWrite(trigger_left, LOW); 
     duration_left = pulseIn(echo_left, HIGH);
     left = duration_left/29/2;
    Serial.print(left);
    Serial.println("");
     digitalWrite(trigger_dir, LOW);
     delayMicroseconds(2);
     digitalWrite(trigger_dir, HIGH);
     delayMicroseconds(5);
     digitalWrite(trigger_dir, LOW); 
     duracao_dir = pulseIn(echo_dir, HIGH);
     direita = duracao_dir/29/2; 
     Serial.print(direita);
     Serial.println("");
     i=analogRead(A5);
     Serial.println("L");
     Serial.print(i);
     Serial.println("L");
     j=analogRead(A4);
      Serial.println("R");
     Serial.print(j);
     Serial.println("R");
     analogWrite(motor_left, 0); 
     analogWrite(motor_dir, 0); 
     analogWrite(l1, 0);           
     analogWrite(l2, 0);          
     analogWrite(d1, 0);            
     analogWrite(d2, 0);           

       if(front >8) 
         {  
          
           
           if(direita >11 && direita<15) 
             {               
               analogWrite(motor_left, cnt);
               analogWrite(motor_dir, 150);
           
               analogWrite(l1, spd);
               analogWrite(l2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, spd);                                                        
             }
         
           if(direita >=15)
             {
               analogWrite(motor_left,zlt);
               analogWrite(motor_dir, spd);
           
               analogWrite(l1, spd);
               analogWrite(l2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, spd);                               
             }
             
                 
           if(direita <=11) 
             {
               analogWrite(motor_left, spd);
               analogWrite(motor_dir, zlt);
           
               analogWrite(l1, spd);
               analogWrite(l2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, spd);                   
             }
         }  
   
              
  if(left <=thr && direita>thr && front <=8) dir(); 
            
    if(left >thr && direita>thr && front <=8) dir();
     
  if(direita <=thr && left >thr && front <=8) esq(); 
       
      if(direita<=thr && left<=thr && front<=8) voltar();                                
   if(j>400 || i>400)
     {
      analogWrite(motor_left, 255);  
     analogWrite(motor_dir, 255); 
     analogWrite(l1, 255);           
     analogWrite(l2, 255);            
     analogWrite(d1, 255);           
     analogWrite(d2, 255);            
     delay(5000);

     }
 
    }
     
     void esq() 
      {
       
        analogWrite(motor_left, rot);
        analogWrite(motor_dir,cnt);
           
        analogWrite(l1, 0);
        analogWrite(l2, spd);
        analogWrite(d1, 0);
        analogWrite(d2, spd);
        delay(700);      
        
      }
    
    void dir()
      { 
        
      
        analogWrite(motor_left,cnt);
        analogWrite(motor_dir, rot);
        
        analogWrite(l1, spd);
        analogWrite(l2, 0);
        analogWrite(d1, spd);
        analogWrite(d2, 0);             
        delay(800);
               
      }
    
    void voltar() 
      {
       
        analogWrite(motor_left,cnt );
        analogWrite(motor_dir, rot);
           
        analogWrite(l1, spd);
        analogWrite(l2, 0);
        analogWrite(d1, spd);
        analogWrite(d2, 0);
        delay(1200); 
         
      }   
  
    
    
    
